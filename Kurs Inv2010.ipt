# Autodesk Inventor part: Standard
## iProperties
Created: 2005-05
Part Number: Standard
Document SubType Name: Modeling
Designer: JWe
Density: 1 g/cm^3
Author: JWe
